# Keil uVision project test_blink.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_blink
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: .\DevRTOS;..\3_keilTiva
  asm define: Stack_Size=1024 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c bsp.c bsp.h list.c list.h activeObject.c activeObject.h
    ./DevRTOS/: devRtos.c devRtos.h devRtosConfig.h queue.c queue.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
